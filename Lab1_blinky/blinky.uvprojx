# Keil uVision project blinky.uvprojx, settings and files
target Tiva (6230000::V6.23::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab1_blinky
  c flags: Optim=4 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA2
  c include: .\src_other;..\..\TivaWare_C_Series-2.2.0.295\inc;..\..\TivaWare_C_Series-2.2.0.295;..\..\TivaWare_C_Series-2.2.0.295\grlib
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group src_other
    ./src_other/: main.c BTN.c LED.c
  group libs
    ../../TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
